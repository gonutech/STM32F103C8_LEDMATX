# Keil uVision project WirelessSensor.uvprojx, settings and files
target WirelessSensor (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WirelessSensor +hex
  AfterMake: BuildOutput\copy_hex.bat
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;../UserDev/AppSW/TaskControl/Include;../UserDev/HwLib;..\UserDev\HwLib\UartDebug\Include;..\UserDev\HwLib\SPISeg7LED\Include;..\UserDev\HwLib\LedMat
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc.c stm32f1xx_hal_tim.c stm32f1xx_hal.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_pwr.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c
  group Application/User
    ../Src/: main.c stm32f1xx_hal_timebase_TIM.c stm32f1xx_it.c usart.c stm32f1xx_hal_msp.c gpio.c freertos.c spi.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c timers.c queue.c event_groups.c tasks.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group AppSW
    ../UserDev/AppSW/TaskControl/: osTaskControlMain.c
  group HwLibSW
    ../UserDev/HwLib/UartDebug/: UartDebugMain.c
    ../UserDev/HwLib/SPISeg7LED/: Seg7LedMain.c
    ../UserDev/HwLib/LedMat/: MAX7219.c
software components: CMSIS:CORE 4.1.0
